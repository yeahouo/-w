# Keil uVision project tracer-car.uvprojx, settings and files
target tracer-car (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: tracer-car +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: C:\ti\mspm0_sdk_2_02_00_05\source\third_party\CMSIS\Core\Include,C:\ti\mspm0_sdk_2_02_00_05\source,..\Application,..\Algorithm,..\Module,..\Port,..\BSP,.
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: C:\ti\mspm0_sdk_2_02_00_05\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Application
    ../Application/: main.c fsm.c
  group Algorithm
    ../Algorithm/: pid.c motion.c tracker.c line_tracker.c
  group Module
    ../Module/: motor.c encoder.c log.c errcode.c telemetry.c led_status.c uart_vision.c oled.c button.c line_sensor.c motor_drive.c tm1637.c uart_debug.c
  group BSP
    ./: tracer-car.syscfg startup_mspm0g350x_uvision.s ti_msp_dl_config.h ti_msp_dl_config.c
    ../BSP/: port_min.c
